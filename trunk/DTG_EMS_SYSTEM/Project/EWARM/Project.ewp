# IAR project Project.ewp, settings and files
configuration STM3220F_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM3220F_EVAL; USE_USB_OTG_FS; RTC_CLOCK_SOURCE_LSE
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\Common; ..\..\Utilities\STM32_EVAL\STM3220F_EVAL; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\Usb; ..\Usb\Inc; ..\Usb\src; ..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UpdateDTG.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_stm32f2xx.c
  group EWARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group FAT_FS
    ../USB/src/option/: ccsbcs.c
    ../USB/src/: fattime.c ff.c
  group History
    ../: Example.txt history.txt
  group History/STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: vssver.scc
  group USB_DEIVCE/CLASS/CDC
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_DEIVCE/LIBRARY
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c
  group USB_HOST/Class/MSC
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_HOST/Core
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_HOST/Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group User
    ../: Adc_Process.c DAC_Control.c Display.c Drive_Process.c Eeprom.c Ems_System.c flash_if.c fsmc_nand.c GPSLIB.c GraphicLcd.c i2c_ee.c Key_Process.c Log.c main.c Memory.c nand_if.c PC_COM.c RTC.c Serial.c spi_flash.c stm32f2xx_it.c TestMode.c Tilt.c usbd_cdc_vcp.c usbd_usr.c Voice.c Wifi.c
    ../USB/: usb_bsp.c usbh_usr.c
  group User/inc
    ../: Adc_Process.h DAC_Control.h Display.h Drive_Process.h Eeprom.h EMS_System.h flash_if.h font.h font16x16.h font8x16.h fsmc_nand.h GPSLib.h GraphicLcd.h History.h i2c_ee.h Key_Process.h Log.h main.h Memory.h nand_if.h PC_COM.h RTC.h serial.h spi_flash.h stm32f2xx_it.h TestMode.h Tilt.h usbd_cdc_vcp.h usbd_conf.h Voice.h Wifi.h
    ../USB/: usb_conf.h usbh_conf.h usbh_usr.h
