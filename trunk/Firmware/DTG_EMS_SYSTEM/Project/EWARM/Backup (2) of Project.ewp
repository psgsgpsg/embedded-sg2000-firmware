# IAR project Backup (2) of Project.ewp, settings and files
configuration STM3220F_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM3220F_EVAL; USE_USB_OTG_FS; USE_ULPI_PHY; RTC_CLOCK_SOURCE_LSE
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\Common; ..\..\Utilities\STM32_EVAL\STM3220F_EVAL; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_stm32f2xx.c
  group EWARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group History
    ../: history.txt
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: vssver.scc
  group User
    ../: DAC_Control.c Display.c Ems_System.c fsmc_nand.c GPSLIB.c GraphicLcd.c i2c_ee.c Key_Process.c Log.c main.c Memory.c RTC.c Serial.c Serial.h spi_flash.c stm32f2xx_it.c Tilt.c Voice.c
  group User/inc
    ../: DAC_Control.h Display.h Ems_System.h font.h font16x16.h font8x16.h fsmc_nand.h GPSLib.h GraphicLcd.h i2c_ee.h Key_Process.h Log.h main.h Memory.h RTC.h spi_flash.h stm32f2xx_it.h Tilt.h Voice.h
